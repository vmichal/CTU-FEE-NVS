# Keil uVision project LED_TLC.uvproj, settings and files
target STM32F1xx (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: StaircaseAutomat
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Code
    ./: STM32F10x.s LED_TLC.asm CorePeripherals.s SysTick.s GPIO.s RCC.s
  group Help
    ./: ReadMe.txt
